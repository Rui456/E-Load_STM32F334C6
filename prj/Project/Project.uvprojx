# Keil uVision project Project.uvprojx, settings and files
target STM32F334x8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334C6Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F334x8
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8
  c misc: --C99
  c include: ..\;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\Libraries\STM32F30x_I2C_CPAL_Driver\inc;..\Application;..\Drivers
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group /MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f334x8.s
  group STM32F30x_StdPeriph_Driver
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group User
    ../Application/: main.c stm32f30x_it.c system_stm32f30x.c
  group Drivers
    ../Drivers/: dma_uart.c oled.c delay.c adc_key.c dac.c dac.h
